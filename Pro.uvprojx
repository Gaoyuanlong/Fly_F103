# Keil uVision project Pro.uvprojx, settings and files
target ST (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucos_II +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\FWLIB\inc;.\STARTUP;.\USER;.\APP;.\UCOS_II\Ports;.\UCOS_II\Source;.\USER\APP\Inc;.\USER\Driver\Inc;.\USER\Ports\Inc;.\USER\Others\Inc;.\USER\Driver\SDCard
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./USER/: main.c stm32f10x_it.c Para.c Communicate.c
    ./USER/APP/Src/: APP_Gather.c APP_Show.c
  group Driver
    ./USER/Driver/Src/: Led.c RTK.c TFT1_44.c SDCard.c
  group Others
    ./USER/Others/Src/: Queue.c
  group BSP
    ./USER/Ports/Src/: BSP.c ADC.c Time.c USART1.c USART2.c USART3.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ./STARTUP/: startup_stm32f10x_md.s
  group UCOS_II/Ports
    ./UCOS_II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOS_II/Source
    ./UCOS_II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group SD_FAT
    ./USER/Driver/SDCard/: diskio.c ff.c
